Commit message: add xacro support

File: urdf/arm.urdf (robot description, URDF)
Before this commit: robot arm_simulation, 6 links, 5 joints
Links:
- link base_link: mass 0.65122 -> None
